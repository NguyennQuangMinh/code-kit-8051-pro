# Keil uVision project hien thi gia tri nhiet do len LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: hien thi gia tri nhiet do len LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ../../../Library/Delay/: Delay.c
    ../../../Library/One Wire/: OneWire.c
    ../../../Library/T0_Delay_us/: T0_Delay_us.c
    ../../../Library/LCD16x2_4bit/: LCD4.c
