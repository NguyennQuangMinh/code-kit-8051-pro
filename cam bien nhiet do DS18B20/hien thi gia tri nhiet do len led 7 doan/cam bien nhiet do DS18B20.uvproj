# Keil uVision project cam bien nhiet do DS18B20.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: cam bien nhiet do DS18B20 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ../../Library/Delay/: Delay.c
    ../../../Library/T0_Delay_us/: T0_Delay_us.c
    ../../../Library/One Wire/: OneWire.c
