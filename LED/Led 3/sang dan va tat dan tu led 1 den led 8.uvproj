# Keil uVision project sang dan va tat dan tu led 1 den led 8.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: sang dan va tat dan tu led 1 den led 8 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
